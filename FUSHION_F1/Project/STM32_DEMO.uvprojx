# Keil uVision project STM32_DEMO.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32_DEMO +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\USER;..\Libraries\src;..\Libraries\inc;..\Startup;..\CMSIS\CM3\CoreSupport;..\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\APP;..\FUSHION
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../USER/: main.c
    ../APP/: delay.c usart.c dma.c stmflash.c
  group Libraries
    ../Libraries/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_exti.c
  group Startup
    ../USER/: stm32f10x_it.c
    ../CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Startup/: startup_stm32f10x_md.s
  group Mems
    ../APP/: mpu6050.c i2c_soft.c sonar.c
  group Math
    ../APP/: mymath.c imu.c filter.c
  group Fusion
    ../FUSHION/: ukf_task.c KF_OLDX_NAV.c rtGetNaN.c rtGetInf.c rt_nonfinite.c
software components: CMSIS:CORE 4.3.0
